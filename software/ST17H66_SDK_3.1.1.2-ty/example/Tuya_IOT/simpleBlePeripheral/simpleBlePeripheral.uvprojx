# Keil uVision project simpleBlePeripheral.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: simpleBlePeripheral +hex
  AfterMake: fromelf.exe .\Objects\simpleBlePeripheral.axf --i32combined --output .\bin\simpleBlePeripheral.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CUSTOMIZED_TUYA_BLE_CONFIG_FILE=<custom_tuya_ble_config.h>  CFG_CP DEBUG_INFO=0 MTU_SIZE=247 HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0  _BUILD_FOR_DTM_=0 DBG_ROM_MAIN=0 APP_CFG=0  OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_SLEEP DEF_GAPBOND_MGR_ENABLE=0 USE_FS=0 MAX_NUM_LL_CONN=1
  c misc: --diag_suppress=177,550,186,545,188,68,940 -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: ..\..\..\components\inc;..\..\..\components\ble\controller;..\..\..\components\osal\include;..\..\..\components\common;..\..\..\components\ble\include;..\..\..\components\ble\hci;..\..\..\components\ble\host;..\..\..\components\Profiles\ota_app;..\..\..\components\Profiles\DevInfo;..\..\..\components\Profiles\SimpleProfile;..\..\..\components\Profiles\Roles;.\source;..\..\..\components\libraries\crc16;..\..\..\components\driver\clock;..\..\..\components\arch\cm0;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\gpio;..\..\..\components\driver\timer;..\..\..\misc;..\..\..\components\driver\log;..\..\..\components\libraries\cliface;..\..\..\components\driver\key;..\..\..\components\driver\pwm;..\..\..\components\driver\adc;..\..\..\components\driver\spi;..\..\..\components\driver\i2c;..\..\..\components\driver\flash;..\..\..\components\libraries\fs;..\tuya_ble_sdk_demo\app;..\tuya_ble_sdk_demo\board;..\tuya_ble_sdk_demo\board\include;..\tuya_ble_sdk_demo\board\tuyable\ota;..\tuya_ble_sdk_demo\board\tuyable\service;..\tuya_ble_sdk_demo\board\tuyable\tuya_ble_port;..\tuya_ble_sdk_demo\components\ty_util;..\tuya_ble_sdk_demo\components\ty_oled;..\tuya_ble_sdk_demo\components\ty_key_press;..\tuya_ble_sdk_demo\components\external\easylogger\inc;..\tuya_ble_sdk_demo\tuya_ble_sdk;..\tuya_ble_sdk_demo\tuya_ble_sdk\app\product_test;..\tuya_ble_sdk_demo\tuya_ble_sdk\app\uart_common;..\tuya_ble_sdk_demo\tuya_ble_sdk\extern_components\mbedtls;..\tuya_ble_sdk_demo\tuya_ble_sdk\port;..\tuya_ble_sdk_demo\tuya_ble_sdk\sdk\include;..\tuya_ble_sdk_demo\tuya_ble_sdk\sdk\lib;..\..\..\components\libraries\fs;..\tuya_mcu_sdk;.\source
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group tuya_ble_sdk_demo
    ../tuya_ble_sdk_demo/app/: tuya_ble_sdk_demo.c tuya_ble_sdk_test.c tuya_ble_bulk_data_demo.c tuya_ble_product_test_demo.c
    ./source/: chx_driver.c key_driver.c led_driver.c ty_mcu_sdk_app.c ty_dev_config.h
  group tuya_ble_sdk
    ../tuya_ble_sdk_demo/tuya_ble_sdk/sdk/src/: tuya_ble_api.c tuya_ble_utils.c tuya_ble_heap.c tuya_ble_main.c tuya_ble_mem.c tuya_ble_event.c tuya_ble_queue.c tuya_ble_storage.c tuya_ble_unix_time.c tuya_ble_bulk_data.c tuya_ble_data_handler.c tuya_ble_event_handler.c tuya_ble_feature_weather.c tuya_ble_gatt_send_queue.c tuya_ble_mutli_tsf_protocol.c tuya_ble_event_handler_weak.c
    ../tuya_ble_sdk_demo/tuya_ble_sdk/app/product_test/: tuya_ble_app_production_test.c
    ../tuya_ble_sdk_demo/tuya_ble_sdk/app/uart_common/: tuya_ble_app_uart_common_handler.c
    ../tuya_ble_sdk_demo/tuya_ble_sdk/sdk/lib/: tuya_ble_sdk_lib_arm_m0_keil.lib
  group tuya_mcu_sdk
    ../tuya_mcu_sdk/: mcu_api.c protocol.c system.c
  group component/ty
    ../tuya_ble_sdk_demo/components/ty_oled/: ty_oled.c
    ../tuya_ble_sdk_demo/components/ty_key_press/: ty_key_press.c
    ../tuya_ble_sdk_demo/components/ty_util/: ty_util.c
  group component/mbedtls
    ../tuya_ble_sdk_demo/tuya_ble_sdk/extern_components/mbedtls/: aes.c md5.c sha1.c sha256.c
  group component/easylogger
    ../tuya_ble_sdk_demo/components/external/easylogger/inc/: elog_cfg.h elog.h
    ../tuya_ble_sdk_demo/components/external/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../tuya_ble_sdk_demo/components/external/easylogger/port/: elog_port.c
  group board
    ../tuya_ble_sdk_demo/board/tuyable/ty_board/: ty_adc.c ty_ble.c ty_flash.c ty_i2c.c ty_pin.c ty_pwm.c ty_rtc.c ty_spi.c ty_system.c ty_timer.c ty_uart.c
    ../tuya_ble_sdk_demo/board/tuyable/tuya_ble_port/: tuya_ble_port.c tuya_ble_port.h custom_tuya_ble_config.h
    ../tuya_ble_sdk_demo/board/tuyable/ota/: tuya_ble_ota.h tuya_ble_ota.c
  group Application
    ./: main.c
  group driver
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/timer/: timer.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/key/: key.c
    ../../../components/driver/pwm/: pwm.c
    ../../../components/osal/snv/: osal_snv.c
    ../../../components/driver/flash/: flash.c
    ../../../components/driver/adc/: adc.c
    ../../../components/driver/i2c/: i2c.c
    ../../../components/driver/spi/: spi.c
  group profile
    ../../../components/profiles/Roles/: central.c gap.c gapbondmgr.c gapgattserver.c peripheral.c
    ../../../components/profiles/GATT/: gattservapp.c
    ../tuya_ble_sdk_demo/board/tuyable/service/: tuya_ble_service.c tuya_ble_service.h
  group jump
    ../../../misc/: jump_table.c
  group lib
    ../../../lib/: rf.lib ble_host.lib
  group simpleBlePeripheral
    ./source/: OSAL_SimpleBLEPeripheral.c simpleBLEPeripheral.c SimpleBLEPeripheral_Main.c
    ../../../components/libraries/fs/: fs.c fs.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
